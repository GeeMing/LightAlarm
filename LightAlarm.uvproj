# Keil uVision project LightAlarm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: LightAlarm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c lcd1602.c key.c menu.c ds1302.c STARTUP.A51
